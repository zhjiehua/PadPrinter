# IAR project PadPrinter.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x300
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: __STM8S903; __STM8S103; STM8S005
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER; ..\Hardware; ..\Logic; ..\SimPLC
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: PadPrinter.hex
  ILINK.IlinkOutputFile: PadPrinter.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG; __STM8S903; STM8S005
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\Hardware; ..\Logic; ..\SimPLC; ..\USER
  OBJCOPY.OOCOutputFile: PadPrinter.srec
  group FWlib
    ../FWlib/src/: stm8s_beep.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_tim5.c stm8s_uart1.c stm8s_uart2.c
  group Hardware
    ../Hardware/: 24cxx.c beep.c flash_eeprom.c i2c_eeprom.c io.c myiic.c option.c tim1.c tim2.c tim5.c tm1638.c
  group Logic
    ../Logic/: actions.c management.c misc.c project.c
  group SimPLC
    ../SimPLC/: simplc_io.c simplc_timer.c
  group USER
    ../USER/: main.c stm8s_it.c sysclock.c uart1.c uart2.c
