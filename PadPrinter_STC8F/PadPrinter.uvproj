# Keil uVision project PadPrinter.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: PadPrinter +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Logic;.\HARDWARE;.\SimPLC
  group Source Group 1
    ./: main.c STARTUP.A51
  group HARDWARE
    ./HARDWARE/: io.c timer.c uart.c tm1638.c 24cxx.c myiic.c iic.c
  group SimPLC
    ./SimPLC/: simplc_io.c simplc_timer.c
  group Logic
    ./Logic/: actions.c management.c misc.c project.c normal.c ProgramSelect.c ProgramSelf.c KeyLogic.c
